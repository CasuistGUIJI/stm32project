# Keil uVision project project2.uvprojx, settings and files
target project2 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project2 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\USER;..\LIB\inc;..\CORE;..\HARDWARE;..\SYSTEM;..\FreeRTOS\include;..\FreeRTOS\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group lib
    ../LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_adc.c stm32f4xx_spi.c
  group hardware
    ../HARDWARE/: led.c key.c delay.c exti.c pwm.c tim.c usart.c dht11.c sr04.c beep.c rtc.c iwdg.c flash.c adc.c project.c spi.c I2C.c oled.c base64.c hmac_sha1.c
  group core
    ../CORE/: startup_stm32f40_41xxx.s
  group NET
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/MQTT/: MqttKit.c
    ../HARDWARE/ONENET/: onenet.c
    ../HARDWARE/cJSON/: cJSON.c
  group FreeRTOS
    ../FreeRTOS/CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/heap/: heap_4.c
    ../FreeRTOS/port/: port.c
